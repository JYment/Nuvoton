# Keil uVision project Blink.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M0516LDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Blink
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Library
    E:/nuvoton/M051_Series_BSP_CMSIS_V3.01.004/Library/StdDriver/src/: acmp.c adc.c clk.c ebi.c FMC.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group CMSIS
    E:/nuvoton/M051_Series_BSP_CMSIS_V3.01.004/Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
    E:/nuvoton/M051_Series_BSP_CMSIS_V3.01.004/Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group User
    ./: main.c device_func.c common.h device_func.h
