# Keil uVision project External_INT.uvproj, settings and files
target External_INT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: (Generic) M051 Series Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: External_INT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\StdDriver\inc;..\3_ExGPIO_INTERRUPT
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group Library
    ../Library/StdDriver/src/: acmp.c adc.c clk.c ebi.c FMC.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group User
    ./: main.c device_func.c device_func.h common.h IRQ_Handler.c IRQ_Handler.h
